FILESEXTRAPATHS:prepend := "${THISDIR}/linux-xlnx:"
SRC_URI += "file://usbserial.cfg"
